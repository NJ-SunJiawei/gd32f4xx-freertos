# Keil uVision project rtosTT.uvprojx, settings and files
target TT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F47 0IK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtosTT
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F470
  c include: ..\App;..\CMSIS;..\Library\Include;..\Driver;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Fatfs\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/: gd32f4xx_it.c gd32f4xx_it.h gd32f4xx_libopt.h main.c systick.c systick.h os_api.h os_api.c
  group CMSIS
    ../CMSIS/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h gd32f4xx.h system_gd32f4xx.c system_gd32f4xx.h
  group Library
    ../Library/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../Startup/: startup_gd32f450_470.s
  group Freertos
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/Source/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreertosPortable
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group Fatfs
    ../Fatfs/source/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
  group Driver
    ../Driver/: drv_gd25q40.c drv_gd25q40.h drv_gd25qxx.c drv_gd25qxx.h drv_sdcard.c drv_sdcard.h gd32f450i_eval.c gd32f450i_eval.h
target TT_RAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F47 0IK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: as above
  output: rtosTT
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F470
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT5: ROM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x20020000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
